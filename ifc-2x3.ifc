Properties of the parts of a building model (IFC2X3)

# File
Description: Raumtemperaturfühler, KTY 81-121, Aufputz superflach, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: SA140017, Raumtemperaturfühler, KTY 81-121, Aufputz superflach
In: Raum
Description: Aufputz-Raumtemperaturfühler mit innenliegendem Sensor zur Temperaturmessung in Wohn- und Geschäftsräumen im superflachem Aufputzgehäuse - nur 13,9 mm tief.; Classification: EC004240 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: SA140017; ModelLabel: BTF2-Y81/121-0000; GlobalTradeItemNumber: 4050528051899; ProductURL: https://alre.de/produkt_SA140017
Pset_Specification - NominalLength: 0.0785 m; NominalWidth: 0.078 m; NominalDepth: 0.0139 m; NetWeight: 0.037
Pset_ALRE_ETIM_Properties - Gehäusefarbe: weiß; Geeignet für Wandmontage: yes; Mit Gehäuse: yes; Art der Spannungsversorgung: ohne; Umgebungstemperatur: -10; Ausführung des elektrischen Anschlusses: Schraubanschluss; Deckelbefestigung: aufrastend; Explosionsgeschützt: no; Schutzart (IP): IP30; Einsatzgebiet: Raum; Geeignet für Flüssigkeiten: no; Geeignet für Gase: yes; Temperaturmessbereich: -10; Sensorelement innerhalb des Gehäuses: yes; Aktive Temperaturmessung: no; Passive Temperaturmessung: yes; Max. Umgebungsfeuchtigkeit (nicht kondensierend): 95; Sensorelement außerhalb des Gehäuses: no; Sensortyp: sonstige; Gehäusehöhe: 78.5; Gehäusebreite: 78; Gehäusetiefe: 13.9; Festes Kabel am Sensor: no; Geeignet für Luft: yes; ETIM-Klasse: EC004240; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-SA140017.pdf
